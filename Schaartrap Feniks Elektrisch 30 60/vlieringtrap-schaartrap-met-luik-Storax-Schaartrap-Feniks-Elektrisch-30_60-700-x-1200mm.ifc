Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 37485995-7e34-42ef-9819-e519b9276c5c.ifc
Time: 2026-08-11T16:22:20
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcStair, vlieringtrap schaartrap met luik Storax - Schaartrap Feniks Elektrisch 30/60 700 x 1200mm
In: Bouwlaag
Material: aluminium
Pset_Data - WUID: AgAAAOqLA0AGAAAA7OoCAAWxXwAAPHsBAHQGAACb6gIAI-wCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIAbOsCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAOqLA0AGAAAA7OoCAAWxXwAAPHsBAHQGAACb6gIAI-wCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIAbOsCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); STABU2: 32.32.11; lengte: 1180 mm; inbouwhoogte: 240 mm; inbouwlengte: 1200 mm; U-waarde: 0,57 w/m²·k; breedte: 680 mm; max. belasting: 200 kg; NAA.K.T: samengesteld_product_generiek; bediening: elektrisch; theoretische levensduur: 50; serie: Schaartrap Feniks Elektrisch 30/60; inbouwbreedte: 700 mm; merk: Storax; beweegbaar: True; omranding: staal; luik: staal; trap: schaarladder Storax - Schaarladder 300mm
